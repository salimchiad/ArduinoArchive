* EESchema Netlist Version 1.1 (Spice format) creation date: 01/05/2014 21:22:55

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
D1  N-000042 N-000034 LED
R1  N-000034 N-000024 R
D2  N-000027 N-000035 LED
R2  N-000035 N-000024 R
D3  N-000028 N-000036 LED
R3  N-000036 N-000024 R
D4  N-000029 N-000037 LED
R4  N-000037 N-000024 R
D5  N-000030 N-000038 LED
R5  N-000038 N-000024 R
D6  N-000031 N-000023 LED
R6  N-000023 N-000024 R
D7  N-000032 N-000025 LED
R7  N-000025 N-000024 R
D8  N-000033 N-000026 LED
R8  N-000026 N-000024 R
U1  N-000027 N-000028 N-000029 N-000030 N-000031 N-000032 N-000033 GND N-000001 N-000019 N-000021 N-000020 N-000018 N-000017 N-000042 VCC 74HC595
D9  N-000009 N-000039 LED
R9  N-000039 N-000024 R
D10  N-000011 N-000040 LED
R10  N-000040 N-000024 R
D11  N-000008 N-000041 LED
R11  N-000041 N-000024 R
D12  N-000002 N-000013 LED
R12  N-000013 N-000024 R
D13  N-000003 N-000014 LED
R13  N-000014 N-000024 R
D14  N-000004 N-000012 LED
R14  N-000012 N-000024 R
D15  N-000022 N-000015 LED
R15  N-000015 N-000024 R
D16  N-000005 N-000016 LED
R16  N-000016 N-000024 R
U2  N-000011 N-000008 N-000002 N-000003 N-000004 N-000022 N-000005 GND ? N-000019 N-000021 N-000020 N-000018 N-000001 N-000009 VCC 74HC595
P1  N-000018 N-000019 N-000017 N-000020 N-000021 CONN_5

.end
